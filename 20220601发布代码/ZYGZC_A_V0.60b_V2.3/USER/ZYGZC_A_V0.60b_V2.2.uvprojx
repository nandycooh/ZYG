# Keil uVision project ZYGZC_A_V0.60b_V2.2.uvprojx, settings and files
target ZYGZC_A_V0.60b_V2.2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZYGZC_A_V0.60b_V2.2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FUNCTION\DATA;..\FUNCTION\FLASH;..\FUNCTION\LED;..\FUNCTION\MD5;..\FUNCTION\MOTOR;..\FUNCTION\POWER;..\FUNCTION\PROTOCOL;..\FUNCTION\SI4438;..\FUNCTION\TIME;..\FUNCTION\USRC322;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FUNCTION\EMSERIAL;..\FUNCTION\SPI
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FUNCTION
    ../FUNCTION/FLASH/: hal_flash.c
    ../FUNCTION/LED/: led.c
    ../FUNCTION/MD5/: md5.c
    ../FUNCTION/MOTOR/: motor.c
    ../FUNCTION/POWER/: power.c
    ../FUNCTION/DATA/: attitude.c
    ../FUNCTION/PROTOCOL/: protocol.c
    ../FUNCTION/USRC322/: usr_c322.c
    ../FUNCTION/SI4438/: drv_SI4438.c
    ../FUNCTION/SPI/: drv_spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_flash.c
  group FreeRTOS_CORE
    ../FreeRTOS/: list.c tasks.c timers.c queue.c croutine.c stream_buffer.c event_groups.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: README.TXT
