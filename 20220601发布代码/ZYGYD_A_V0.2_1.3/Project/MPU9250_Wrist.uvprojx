# Keil uVision project MPU9250_Wrist.uvprojx, settings and files
target Wrist (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU9250_Wrist +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F1
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\User\MPU6050\driver\eMPL;..\User\MPU6050\driver\include;..\User\MPU6050\driver\stm32L;..\User\MPU6050\eMPL-hal;..\User\MPU6050\mllite;..\User\MPU6050\mpl;..\User\timer2;..\User\i2c
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Lib
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/Exti/: bsp_exti.c
    ../User/i2c/: bsp_i2c.c
    ../User/Led/: bsp_led.c
    ../User/SysTick/: bsp_SysTick.c
    ../User/usart/: bsp_usart.c USART2.c fifo.c
    ../User/: main.c key.c crc.c flash.c
    ../User/timer2/: timer2.c
  group MPU_eMPL
    ../User/MPU6050/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../User/MPU6050/driver/stm32L/: log_stm32.c
    ../User/MPU6050/eMPL-hal/: eMPL_outputs.c
  group MPU_mllite
    ../User/MPU6050/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group MPU_mpl
    ../User/MPU6050/mpl/: libmpllib.lib
  group DOC
    ../Doc/: readme.txt
