# Keil uVision project ZYGSQ_V0.51_V2.0.uvprojx, settings and files
target ZYGSQ_V0.51_V2.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZYGSQ_V0.51_V2.0 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD, USE_STM3210B_EVAL
  c misc: --c99
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FUNCTION\ADC;..\FUNCTION\SPI;..\FUNCTION\SI4438;..\FUNCTION\FLASH
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FUNCTION
    ../FUNCTION/TIME/: hal_timer.c
    ../FUNCTION/CRC/: crc.c
    ../FUNCTION/LED/: rgb_led.c
    ../FUNCTION/PERIPHERAL/: peripheral.c
    ../FUNCTION/POWER/: powerManage.c
    ../FUNCTION/PROTOCOL/: protocol.c
    ../FUNCTION/RECOIL/: recoil.c
    ../FUNCTION/SI4438/: drv_SI4438.c
    ../FUNCTION/SPI/: drv_spi.c
    ../FUNCTION/FLASH/: hal_flash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_tim.c stm32f10x_flash.c
  group README
    ../: README.TXT
